# IAR project GPIO_Toggle.ewp, settings and files
configuration APM32F003 (ARM, debug)
  General.OGChipSelectEditMenu: APM32F003F6 Geehy APM32F003F6
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: BOARD_APM32F003_MINI
  ICCARM.CCIncludePath2: ..\..\Include; ..\..\..\..\..\Boards; ..\..\..\..\..\Libraries\APM32F00x_StdPeriphDriver\inc; ..\..\..\..\..\Libraries\CMSIS\Include; ..\..\..\..\..\Libraries\Device\Geehy\APM32F00x\Include
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: ADC_Channel_2.srec
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  group Application
    ../../Source/: apm32f00x_int.c main.c
  group Board
    ../../../../../Boards/: Board.c
  group CMSIS
    ../../../../../Libraries/Device/Geehy/APM32F00x/Source/iar/: startup_apm32f00x.s
    ../../Source/: system_apm32f00x.c
  group StdPeriphLib
    ../../../../../Libraries/APM32F00x_StdPeriphDriver/src/: apm32f00x_adc.c apm32f00x_buzzer.c apm32f00x_eint.c apm32f00x_fmc.c apm32f00x_gpio.c apm32f00x_i2c.c apm32f00x_iwdt.c apm32f00x_misc.c apm32f00x_rcm.c apm32f00x_spi.c apm32f00x_tmr1.c apm32f00x_tmr2.c apm32f00x_tmr4.c apm32f00x_usart.c apm32f00x_wupt.c apm32f00x_wwdt.c
