# Keil uVision project GPIO_Toggle.uvprojx, settings and files
target GPIO_Toggle (6220000::V6.22::ARMCLANG)
  device: APM32F003F6 Geehy
  pack: Geehy.APM32F00x_DFP.1.0.5
  cpu: IRAM(0x20000000,0x1000) IROM(0x00000000,0x8000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: GPIO_Toggle +hex
  c flags: Optim=2 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=5 wLevel=3
  c define: BOARD_APM32F003_MINI
  c include: ..\..\..\..\..\Libraries\APM32F00x_StdPeriphDriver\inc;..\..\..\..\..\Libraries\CMSIS\Include;..\..\..\..\..\Libraries\Device\Geehy\APM32F00x\Include;..\..\Include;..\..\..\..\..\Boards;..\..\..\..\..\Boards\Board_APM32F002_MINI
  memory RVCT4: ROM 0x0 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x1000
  group CMSIS
    ../../Source/: system_apm32f00x.c
    ../../../../../Libraries/Device/Geehy/APM32F00x/Source/ARM/: startup_apm32f00x.s
  group StdPeriphDriver
    ../../../../../Libraries/APM32F00x_StdPeriphDriver/src/: apm32f00x_gpio.c apm32f00x_eint.c apm32f00x_adc.c apm32f00x_buzzer.c apm32f00x_fmc.c apm32f00x_i2c.c apm32f00x_iwdt.c apm32f00x_misc.c apm32f00x_rcm.c apm32f00x_spi.c apm32f00x_tmr1.c apm32f00x_tmr2.c apm32f00x_tmr4.c apm32f00x_usart.c apm32f00x_wupt.c apm32f00x_wwdt.c
  group Application
    ../../Source/: apm32f00x_int.c main.c
